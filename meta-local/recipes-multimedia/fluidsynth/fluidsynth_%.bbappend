# Only alsa is needed for fluidsynth to work, keep image small
PACKAGECONFIG = "alsa"
# PACKAGECONFIG:remove = "pulseaudio"
