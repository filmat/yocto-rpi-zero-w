BB_GIT_SHALLOW = "1"
BB_GIT_SHALLOW_DEPTH = "1"
